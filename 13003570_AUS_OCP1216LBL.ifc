Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 7a2e0b24-286a-4d5b-bc57-26d28c63ee23, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-02T07:23:02+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13003570_AUS_OCP1216LBL:331B1PCL_AUS_13003570_OCP1216LBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_OUT, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 331B1PCL_AUS_13003570_OCP1216LBL; sets with these values: 2
